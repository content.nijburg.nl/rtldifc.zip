Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: c9920423-99e9-47a4-8cd4-f46c4f9ac75a, NumberOfSaves: 32]
File name: Project Number
Time: 2024-01-18T14:02:10+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, InPort_1708368_1
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: NLRSen_AT_UN_RTLD_Supply_Solid_Air:200, NLRSen_AT_UN_RTLD_Supply_Solid_Air:200:1708368
In: Default
Type - Description: Round flanged Louvre supply grill, Type RTLD; PredefinedType: DIFFUSER; Material: RAL9010, Sendzimir verzinkt
Type - Other - Category: Air Terminals; Family Name: NLRSen_AT_UN_RTLD_Supply_Solid_Air; SACS_Base_Index: 2
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - SACS_Plenum_A: 260 mm; SACS_Plenum_D1: 198 mm; SACS_Plenum_D2: 198 mm; SACS_Plenum_G: 245 mm; SACS_Plenum_H: 245 mm; SACS_Plenum_K: 115 mm
Type - General - Lookup_Article_Codes: Grill_Article_Codes; Lookup_Article_Data: RTLD_Article_Data; Lookup_Article_Names: Grill_Article_Names; Lookup_Grill_Factors: Grill_Selection_Factors; SACS_Revised_ by: J. Feeke; SACS_Revision_Date: 2019-10-01; SACS_Revision_Number: 2.03
Type - Identity Data - Assembly Code: 57.71; Cost: 0; Description: Round flanged Louvre supply grill, Type RTLD; Manufacturer: Solid Air Climate Solutions; Model: RTLD; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 2019-10-01; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 2.03; NLRS_C_description: Round flanged Louvre supply grill, Type RTLD; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Comments: Please make sure flow is set to m3/h!; Type Name: 200; URL: https://solid-air.nl/producten/roosters/plafondroosters/wervelroosters/rtfo
Type - Mechanical - Flow - Max Flow: 150 dm3/s; Min Flow: 50 dm3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.71 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 200; sets with these values: 2
Other - Family: NLRSen_AT_UN_RTLD_Supply_Solid_Air; Family and Type: NLRSen_AT_UN_RTLD_Supply_Solid_Air: 200; SACS_Arrow_Start: 237.5 mm; Type: 200; Type Id: 1708338
Model Properties - SACS_Color_Ral: yes; SACS_Connector_Top: no; SACS_Damper_Open_%: 100; SACS_Lined_Plenum: yes; SACS_Mounting_Ring: no; SACS_Standard_Color: yes; SACS_Volume_Damper: no
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.362363 m2; NLRS_M_c01_diameter: 200 mm; SACS_Plenum_Height: 378 mm; Volume: 0.000444684 m3
Identity Data - Mark: 7477; NLRS_C_materiaal_kleur: Ral 9010; NLRS_C_model: RTLDOR 200; SACS_Article_Code: 8051000179; SACS_Gross_Cost: 158; SACS_Price_Version: 201901
Materials and Finishes - SACS_Color: Ral 9010; SACS_Face_Color: RAL9010; SACS_Lining_Material: Armaflex; SACS_Lining_Thickness: 12 mm
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_DbA: 28; SACS_Max_Ploss: 35 Pa; SACS_Primairy_Air_Temperature: 15 C; SACS_Room_Temperature: 25 C; System Classification: Supply Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0; SACS_Throw: 0 mm
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Flow out of default specification!
Visibility - SACS_Arrows_and_Throw_Enabled: yes; SACS_Throw_Visible: yes; SACS_Warning_Disable: no
